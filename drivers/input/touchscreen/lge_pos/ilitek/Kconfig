## drivers/input/touchscreen/lge_pos/ilitek/Kconfig
```kconfig
#
# LGE touch core configuration
#
if INPUT_TOUCHSCREEN

source "drivers/input/touchscreen/lge_pos/ilitek/ILI9881H/Kconfig"
endif
```
